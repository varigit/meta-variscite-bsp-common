RDEPENDS:${PN}:append = " \
    openthread \
    openthread-iwxxx-spi \
    var-wireless-utils-ot \
"
